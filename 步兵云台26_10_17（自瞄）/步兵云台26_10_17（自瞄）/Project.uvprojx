# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1U,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c misc: --diag_suppress=188 --no-multibyte-chars --diag_suppress=186
  c include: .\Start;.\Library;.\USB\USB_BOARD;.\USB\USB_CDC;.\USB\USB_DRIVE\inc;.\USB\USB_LIB\inc;.\USB\USB_USER\inc;.\System;.\INS;.\Hardware;.\Motor;.\Function;.\Control;.\CarBody;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group USB
    ./USB/USB_BOARD/: stm324xg_eval.c
    ./USB/USB_CDC/: usbd_cdc_core.c
    ./USB/USB_DRIVE/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./USB/USB_LIB/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USB/USB_USER/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group System
    ./System/: Delay.c Delay.h TIM.c TIM.h UART.c UART.h MyI2C.c MyI2C.h CAN.c CAN.h USB.c USB.h
  group INS
    ./INS/: ins_task.c ins_task.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
  group Hardware
    ./Hardware/: LED.c LED.h Buzzer.c Buzzer.h Remote.c Remote.h BMI088.c BMI088.h IST8310.c IST8310.h Laser.c Laser.h PWM.c PWM.h hipnuc_dec.c hipnuc_dec.h hipnuc_sample.c hipnuc_sample.h HI04.c HI04.h
  group Motor
    ./Motor/: M3508.c M3508.h GM6020.c GM6020.h DM_J4310.c DM_J4310.h
  group Function
    ./Function/: CToC.c CToC.h Warming.c Warming.h LinkCheck.c LinkCheck.h CloseLoopControl.c CloseLoopControl.h AttitudeAlgorithms.c AttitudeAlgorithms.h IMUTemperatureControl.c IMUTemperatureControl.h DebugPort.c DebugPort.h crc_rm.c crc_rm.h
  group Control
    ./Control/: PID.c PID.h
  group CarBody
    ./CarBody/: Visual.c Visual.h Gimbal.c Gimbal.h Keyboard.c Keyboard.h RefereeSystem.c RefereeSystem.h RefereeSystem_CRCTable.c
    ./Carbody/: RefereeSystem_CRCTable.h
  group User
    ./User/: main.c RM_C.h Lock.c Lock.h Parameter.h arm_math.h arm_cortexM4lf_math.lib stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
